require include/core-image-renesas-base.inc
require include/core-image-bsp.inc
DISTRO_FEATURES_remove = " wayland"