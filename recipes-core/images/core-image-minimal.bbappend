require include/core-image-bsp.inc
